# Keil uVision project SnakeProject.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SnakeProject
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: snake_utils.c snake.c body.c snake.h snake_utils.h ball.c head.c
  group ::Board Support
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.1.0/Boards/Keil/MCBSTM32C/Common/: ADC.c GLCD_SPI_STM32F10x.c Joystick.c LCD_X_SPI_STM32F10x.c LED.c Touch_STMPE811.c
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.1.0/CMSIS_RTX/LIB/ARM/: RTX_CM3.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.1.0/RTE_Driver/: DMA_STM32F10x.c GPIO_STM32F10x.c
    RTE/Device/STM32F107VC/: RTE_Device.h startup_stm32f10x_cl.s system_stm32f10x.c stm32f10x_conf.h
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.1.0/Device/StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_rcc.c
  group ::Drivers
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.1.0/RTE_Driver/: I2C_STM32F10x.c SPI_STM32F10x.c
software components: CMSIS:CORE 3.30.0, CMSIS:RTOS:Keil RTX 4.74.0, Board Support:MCBSTM32C:A/D Converter 1.0.0, Board Support:MCBSTM32C:Graphic LCD 1.0.0, Board Support:MCBSTM32C:Joystick 1.0.0, Board Support:MCBSTM32C:LED 1.0.0, Board Support:MCBSTM32C:Touchscreen 1.0.0, Board Support:MCBSTM32C:emWin LCD 1.0.0, Device:DMA 1.01.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:RCC 3.5.0, Drivers:I2C 1.01.0, Drivers:SPI 1.03.0
